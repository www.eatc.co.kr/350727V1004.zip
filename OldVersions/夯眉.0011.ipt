# Autodesk Inventor part: 본체
## iProperties
Created: 2013-02
Part Number: 본체
Document SubType Name: Modeling
Designer: 한국산업디자인학원[gmhk.co.kr]
Density: 1 g/cm^3
Author: 한국산업디자인학원[gmhk.co.kr]
